

DEPENDS_append = " rosidl-cmake "
