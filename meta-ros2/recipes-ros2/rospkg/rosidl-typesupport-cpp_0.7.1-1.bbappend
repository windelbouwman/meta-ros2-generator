
DEPENDS_remove = " rosidl-typesupport-opensplice-cpp rosidl-typesupport-connext-cpp "
