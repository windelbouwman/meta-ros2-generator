
DEPENDS_append = " python3-native "

DEPENDS_remove = " python3-dev-native "
