
FILES_${PN}_append = " /usr/share/poco_vendor"