
FILES_${PN}_append = " /usr/share/tinydir_vendor"
