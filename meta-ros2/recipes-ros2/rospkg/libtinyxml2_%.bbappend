
PROVIDES_append = " tinyxml2 "
