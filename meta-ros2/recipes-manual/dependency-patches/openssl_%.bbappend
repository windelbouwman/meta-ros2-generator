
PROVIDES_append = " libssl-dev "
RPROVIDES_${PN}_append = " libssl-dev "
