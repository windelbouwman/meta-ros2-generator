
PROVIDES_append = " python3-pkg-resources "
RPROVIDES_${PN}_append = " python3-pkg-resources "

