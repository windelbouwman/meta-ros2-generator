
PROVIDES_append = " tinyxml2 "
RPROVIDES_${PN}_append = " tinyxml2 "
