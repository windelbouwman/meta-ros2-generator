
PROVIDES_append = " libpoco-dev "
RPROVIDES_${PN}_append = " libpoco-dev "
