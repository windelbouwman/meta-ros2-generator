
PROVIDES_append = " yaml "
RPROVIDES_${PN}_append = " yaml "

