
RPROVIDES_${PN}_append = " python3-yaml "

