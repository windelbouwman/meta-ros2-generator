
DEPENDS_remove = " rosidl-typesupport-opensplice-cpp rosidl-typesupport-connext-cpp libpoco-dev poco-vendor "

RDEPENDS_${PN}_remove = " libpoco-dev poco-vendor "
