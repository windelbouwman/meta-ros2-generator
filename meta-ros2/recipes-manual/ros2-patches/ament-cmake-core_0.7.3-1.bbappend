
DEPENDS_append = " python3-pyparsing-native python3-pyparsing "