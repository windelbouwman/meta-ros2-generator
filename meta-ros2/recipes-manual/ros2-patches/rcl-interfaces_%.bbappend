
FILES_${PN}_append = " /usr/share/rcl_interfaces"

DEPENDS_append = " rosidl-parser "
