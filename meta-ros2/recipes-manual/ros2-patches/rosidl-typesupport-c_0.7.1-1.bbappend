
DEPENDS_remove = " rosidl-typesupport-opensplice-c rosidl-typesupport-connext-c "
