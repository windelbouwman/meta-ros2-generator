

FILES_${PN}_append = " /usr/bin "

