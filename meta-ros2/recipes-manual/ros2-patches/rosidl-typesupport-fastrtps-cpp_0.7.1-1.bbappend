

DEPENDS_append = " fastcdr fastrtps "
