
DEPENDS_append = " rosidl-typesupport-c rosidl-typesupport-cpp "
