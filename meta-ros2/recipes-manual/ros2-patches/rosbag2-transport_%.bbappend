
DEPENDS_append = " python-cmake-module "
