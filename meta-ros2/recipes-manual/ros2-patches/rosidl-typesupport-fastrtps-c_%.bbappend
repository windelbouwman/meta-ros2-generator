

# DEPENDS = "rosidl-parser rosidl-typesupport-interface rmw ament-cmake-native fastrtps-cmake-module-native fastcdr-native fastrtps-native rosidl-cmake-native rosidl-generator-c-native rosidl-typesupport-fastrtps-cpp ament-cmake-native fastrtps-cmake-module-native fastrtps rosidl-cmake-native rosidl-generator-cpp-native rosidl-typesupport-fastrtps-cpp"
DEPENDS_append = " fastcdr fastrtps rosidl-generator-cpp-native rosidl-typesupport-fastrtps-cpp "
DEPENDS_remove = " fastrtps-native rosidl-typesupport-fastrtps-cpp-native "
