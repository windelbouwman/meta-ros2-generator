
DEPENDS_append = " ament-package-native python3-pyparsing-native "
