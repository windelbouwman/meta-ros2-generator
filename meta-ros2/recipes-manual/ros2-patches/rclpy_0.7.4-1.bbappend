

DEPENDS_append = " python3-typing python3-multiprocessing "
