
DEPENDS_append = " \
    python3-numpy \
    python3-numpy-native \
    rosidl-default-runtime \
"
