
RDEPENDS_${PN}_append = " \
    python3-typing \
    python3-multiprocessing \
    rosidl-generator-py \
"

